# Repository moksamedia/pcb-projects

## EAGLE design led-er-v3/led-er-v3-module-f.brd

Board: 2 copper layers, 159.3 x 53.2 mm, 44 parts (0 on the bottom side), 68 nets.

Parts:
+V_LED: 3,17/1,1
C3: 10uF/16V; 0805
C4: 220uF+; E5-8,5
JP1, JP2, JP3: 1X06_SMD_STRAIGHT_ALT
JP_5V, JP_15VIN: 1X02_OVAL
JP_PROG: 1X02_OVAL
JP_SIGOUT: 1X02_OVAL
JP_SIG_IN: 1X06_SMD_STRAIGHT_ALT
LED1: Green; LED5MM
LED-ER1:C5, LED-ER2:C5, LED-ER3:C5, LED-ER4:C5: 1uF/50V; 0805
LED-ER1:C11, LED-ER2:C11, LED-ER3:C11, LED-ER4:C11: 10uF 25V; 0805
LED-ER1:R3, LED-ER2:R3, LED-ER3:R3, LED-ER4:R3: 22K; 0805
LED-ER1:R6, LED-ER2:R6, LED-ER3:R6, LED-ER4:R6: 0207/9
LED-ER1:TLC1, LED-ER2:TLC1, LED-ER3:TLC1, LED-ER4:TLC1: TLC59711; HTSSOP20DAP
LED-ER1:U$6, LED-ER2:U$6, LED-ER3:U$6, LED-ER4:U$6: HEADER-2X8-RIBBON; 2X08_RIBBON
R2: 470; 0805-THM
SUP_5V: 3,17/1,1
TSR1-2450: TSR1-2450; TSR-1
U$1, U$2, U$3, U$4: MOUNTINGHOLE; MOUNTINGHOLE_3.0_PLATED
U$5: TEENSY_LEDER

Connections:
1SCKI: JP_SIG_IN.2, LED-ER1:TLC1.10, U$5.13
1SDTI: JP_SIG_IN.1, LED-ER1:TLC1.9, U$5.11
+5V: JP_5V.2, LED1.A, LED-ER1:C5.1, LED-ER1:C11.1, LED-ER1:TLC1.19, LED-ER1:TLC1.20, LED-ER2:C5.1, LED-ER2:C11.1, LED-ER2:TLC1.19, LED-ER2:TLC1.20, LED-ER3:C5.1, LED-ER3:C11.1, LED-ER3:TLC1.19, LED-ER3:TLC1.20, LED-ER4:C5.1, LED-ER4:C11.1, LED-ER4:TLC1.19, LED-ER4:TLC1.20, SUP_5V.1, TSR1-2450.3, U$5.VIN
GND: C3.2, C4.-, JP_5V.1, JP_15VIN.1, LED-ER1:C5.2, LED-ER1:C11.2, LED-ER1:R3.2, LED-ER1:R6.2, LED-ER1:TLC1.2, LED-ER1:TLC1.EXP, LED-ER2:C5.2, LED-ER2:C11.2, LED-ER2:R3.2, LED-ER2:R6.2, LED-ER2:TLC1.2, LED-ER2:TLC1.EXP, LED-ER3:C5.2, LED-ER3:C11.2, LED-ER3:R3.2, LED-ER3:R6.2, LED-ER3:TLC1.2, LED-ER3:TLC1.EXP, LED-ER4:C5.2, LED-ER4:C11.2, LED-ER4:R3.2, LED-ER4:R6.2, LED-ER4:TLC1.2, LED-ER4:TLC1.EXP, R2.1, TSR1-2450.2, U$5.GND
LED-ER1:B0: LED-ER1:TLC1.5, LED-ER1:U$6.P5
LED-ER1:B1: LED-ER1:TLC1.8, LED-ER1:U$6.P1
LED-ER1:B2: LED-ER1:TLC1.15, LED-ER1:U$6.P13
LED-ER1:B3: LED-ER1:TLC1.18, LED-ER1:U$6.P9
LED-ER1:G0: LED-ER1:TLC1.4, LED-ER1:U$6.P6
LED-ER1:G1: LED-ER1:TLC1.7, LED-ER1:U$6.P2
LED-ER1:G2: LED-ER1:TLC1.14, LED-ER1:U$6.P14
LED-ER1:G3: LED-ER1:TLC1.17, LED-ER1:U$6.P10
LED-ER1:IREF: LED-ER1:R3.1, LED-ER1:R6.1, LED-ER1:TLC1.1
LED-ER1:R0: LED-ER1:TLC1.3, LED-ER1:U$6.P8
LED-ER1:R1: LED-ER1:TLC1.6, LED-ER1:U$6.P4
LED-ER1:R2: LED-ER1:TLC1.13, LED-ER1:U$6.P16
LED-ER1:R3: LED-ER1:TLC1.16, LED-ER1:U$6.P12
LED-ER2:B0: LED-ER2:TLC1.5, LED-ER2:U$6.P5
LED-ER2:B1: LED-ER2:TLC1.8, LED-ER2:U$6.P1
LED-ER2:B2: LED-ER2:TLC1.15, LED-ER2:U$6.P13
LED-ER2:B3: LED-ER2:TLC1.18, LED-ER2:U$6.P9
LED-ER2:G0: LED-ER2:TLC1.4, LED-ER2:U$6.P6
LED-ER2:G1: LED-ER2:TLC1.7, LED-ER2:U$6.P2
LED-ER2:G2: LED-ER2:TLC1.14, LED-ER2:U$6.P14
LED-ER2:G3: LED-ER2:TLC1.17, LED-ER2:U$6.P10
LED-ER2:IREF: LED-ER2:R3.1, LED-ER2:R6.1, LED-ER2:TLC1.1
LED-ER2:R0: LED-ER2:TLC1.3, LED-ER2:U$6.P8
LED-ER2:R1: LED-ER2:TLC1.6, LED-ER2:U$6.P4
LED-ER2:R2: LED-ER2:TLC1.13, LED-ER2:U$6.P16
LED-ER2:R3: LED-ER2:TLC1.16, LED-ER2:U$6.P12
LED-ER3:B0: LED-ER3:TLC1.5, LED-ER3:U$6.P5
LED-ER3:B1: LED-ER3:TLC1.8, LED-ER3:U$6.P1
LED-ER3:B2: LED-ER3:TLC1.15, LED-ER3:U$6.P13
LED-ER3:B3: LED-ER3:TLC1.18, LED-ER3:U$6.P9
LED-ER3:G0: LED-ER3:TLC1.4, LED-ER3:U$6.P6
LED-ER3:G1: LED-ER3:TLC1.7, LED-ER3:U$6.P2
LED-ER3:G2: LED-ER3:TLC1.14, LED-ER3:U$6.P14
LED-ER3:G3: LED-ER3:TLC1.17, LED-ER3:U$6.P10
LED-ER3:IREF: LED-ER3:R3.1, LED-ER3:R6.1, LED-ER3:TLC1.1
LED-ER3:R0: LED-ER3:TLC1.3, LED-ER3:U$6.P8
LED-ER3:R1: LED-ER3:TLC1.6, LED-ER3:U$6.P4
LED-ER3:R2: LED-ER3:TLC1.13, LED-ER3:U$6.P16
LED-ER3:R3: LED-ER3:TLC1.16, LED-ER3:U$6.P12
LED-ER4:B0: LED-ER4:TLC1.5, LED-ER4:U$6.P5
LED-ER4:B1: LED-ER4:TLC1.8, LED-ER4:U$6.P1
LED-ER4:B2: LED-ER4:TLC1.15, LED-ER4:U$6.P13
LED-ER4:B3: LED-ER4:TLC1.18, LED-ER4:U$6.P9
LED-ER4:G0: LED-ER4:TLC1.4, LED-ER4:U$6.P6
LED-ER4:G1: LED-ER4:TLC1.7, LED-ER4:U$6.P2
LED-ER4:G2: LED-ER4:TLC1.14, LED-ER4:U$6.P14
LED-ER4:G3: LED-ER4:TLC1.17, LED-ER4:U$6.P10
LED-ER4:IREF: LED-ER4:R3.1, LED-ER4:R6.1, LED-ER4:TLC1.1
LED-ER4:R0: LED-ER4:TLC1.3, LED-ER4:U$6.P8
LED-ER4:R1: LED-ER4:TLC1.6, LED-ER4:U$6.P4
LED-ER4:R2: LED-ER4:TLC1.13, LED-ER4:U$6.P16
LED-ER4:R3: LED-ER4:TLC1.16, LED-ER4:U$6.P12
unnamed: LED1.K, R2.2
unnamed: JP1.2, LED-ER1:TLC1.11, LED-ER2:TLC1.10
unnamed: JP1.1, LED-ER1:TLC1.12, LED-ER2:TLC1.9
unnamed: JP2.2, LED-ER2:TLC1.11, LED-ER3:TLC1.10
unnamed: JP2.1, LED-ER2:TLC1.12, LED-ER3:TLC1.9
unnamed: JP3.2, LED-ER3:TLC1.11, LED-ER4:TLC1.10
unnamed: JP3.1, LED-ER3:TLC1.12, LED-ER4:TLC1.9
unnamed: JP_SIGOUT.1, LED-ER4:TLC1.11
unnamed: JP_SIGOUT.2, LED-ER4:TLC1.12
unnamed: JP_PROG.1, U$5.GND2
unnamed: JP_PROG.2, U$5.PROG
VIN: +V_LED.1, C3.1, C4.+, JP_15VIN.2, LED-ER1:U$6.P3, LED-ER1:U$6.P7, LED-ER1:U$6.P11, LED-ER1:U$6.P15, LED-ER2:U$6.P3, LED-ER2:U$6.P7, LED-ER2:U$6.P11, LED-ER2:U$6.P15, LED-ER3:U$6.P3, LED-ER3:U$6.P7, LED-ER3:U$6.P11, LED-ER3:U$6.P15, LED-ER4:U$6.P3, LED-ER4:U$6.P7, LED-ER4:U$6.P11, LED-ER4:U$6.P15, TSR1-2450.1

## EAGLE design led-er-v3/led-er-v3-module (copying).brd

Board: 2 copper layers, 158.0 x 92.7 mm, 38 parts (0 on the bottom side), 60 nets.

Parts:
C3: 10uF/16V; 0805
C4: 220uF+; E5-8,5
JP_5V, JP_15VIN, JP_15VIN1: 1X02_OVAL
JP_PROG: 1X02_OVAL
JP_SIGIN: 1X02_OVAL
JP_SIGOUT: 1X02_OVAL
LED1: Green; CHIP-LED0805
LED-ER1:C1, LED-ER1:C3, LED-ER1:C5, LED-ER1:C6: 1uF/50V; 0805
LED-ER1:C2, LED-ER1:C4, LED-ER1:C7, LED-ER1:C11: 10uF 25V; 0805
LED-ER1:R1, LED-ER1:R3, LED-ER1:R4, LED-ER1:R7: 22K; 0805
LED-ER1:R2, LED-ER1:R5, LED-ER1:R6, LED-ER1:R8: 0207/9
LED-ER1:TLC1, LED-ER1:TLC2, LED-ER1:TLC3, LED-ER1:TLC4: TLC59711; HTSSOP20DAP
LED-ER1:U$1, LED-ER1:U$2, LED-ER1:U$3, LED-ER1:U$6: HEADER-2X8-RIBBON; 2X08_RIBBON
R2: 470; 0805
TSR1-2450: TSR1-2450; TSR-1
U$1, U$3: MOUNTINGHOLE; MOUNTINGHOLE_3.0_PLATED
U$5: TEENSY_LEDER

Connections:
1SCKI: JP_SIGIN.2, LED-ER1:TLC1.10, LED-ER1:TLC2.10, LED-ER1:TLC3.10, LED-ER1:TLC4.10, U$5.13
1SDTI: JP_SIGIN.1, LED-ER1:TLC1.9, LED-ER1:TLC2.9, LED-ER1:TLC3.9, LED-ER1:TLC4.9, U$5.11
+5V: JP_5V.2, LED-ER1:C1.1, LED-ER1:C2.1, LED-ER1:C3.1, LED-ER1:C4.1, LED-ER1:C5.1, LED-ER1:C6.1, LED-ER1:C7.1, LED-ER1:C11.1, LED-ER1:TLC1.19, LED-ER1:TLC1.20, LED-ER1:TLC2.19, LED-ER1:TLC2.20, LED-ER1:TLC3.19, LED-ER1:TLC3.20, LED-ER1:TLC4.19, LED-ER1:TLC4.20, TSR1-2450.3, U$5.VIN
+15V: C3.1, C4.+, JP_15VIN.2, JP_15VIN1.2, LED-ER1:U$1.P3, LED-ER1:U$1.P7, LED-ER1:U$1.P9, LED-ER1:U$1.P13, LED-ER1:U$2.P3, LED-ER1:U$2.P7, LED-ER1:U$2.P9, LED-ER1:U$2.P13, LED-ER1:U$3.P3, LED-ER1:U$3.P7, LED-ER1:U$3.P9, LED-ER1:U$3.P13, LED-ER1:U$6.P3, LED-ER1:U$6.P7, LED-ER1:U$6.P9, LED-ER1:U$6.P13, TSR1-2450.1
GND: C3.2, C4.-, JP_5V.1, JP_15VIN.1, JP_15VIN1.1, LED-ER1:C1.2, LED-ER1:C2.2, LED-ER1:C3.2, LED-ER1:C4.2, LED-ER1:C5.2, LED-ER1:C6.2, LED-ER1:C7.2, LED-ER1:C11.2, LED-ER1:R1.2, LED-ER1:R2.2, LED-ER1:R3.2, LED-ER1:R4.2, LED-ER1:R5.2, LED-ER1:R6.2, LED-ER1:R7.2, LED-ER1:R8.2, LED-ER1:TLC1.2, LED-ER1:TLC1.EXP, LED-ER1:TLC2.2, LED-ER1:TLC2.EXP, LED-ER1:TLC3.2, LED-ER1:TLC3.EXP, LED-ER1:TLC4.2, LED-ER1:TLC4.EXP, R2.1, TSR1-2450.2, U$5.GND
LED-ER1:B0: LED-ER1:TLC1.5, LED-ER1:U$6.P6
LED-ER1:B1: LED-ER1:TLC1.8, LED-ER1:U$6.P2
LED-ER1:B2: LED-ER1:TLC1.15, LED-ER1:U$6.P14
LED-ER1:B3: LED-ER1:TLC1.18, LED-ER1:U$6.P10
LED-ER1:B4: LED-ER1:TLC2.8, LED-ER1:U$1.P2
LED-ER1:B5: LED-ER1:TLC2.5, LED-ER1:U$1.P6
LED-ER1:B6: LED-ER1:TLC2.15, LED-ER1:U$1.P14
LED-ER1:B7: LED-ER1:TLC2.18, LED-ER1:U$1.P10
LED-ER1:B8: LED-ER1:TLC3.8, LED-ER1:U$2.P2
LED-ER1:B9: LED-ER1:TLC3.5, LED-ER1:U$2.P6
LED-ER1:B10: LED-ER1:TLC3.15, LED-ER1:U$2.P14
LED-ER1:B11: LED-ER1:TLC3.18, LED-ER1:U$2.P10
LED-ER1:B12: LED-ER1:TLC4.8, LED-ER1:U$3.P2
LED-ER1:B13: LED-ER1:TLC4.5, LED-ER1:U$3.P6
LED-ER1:B14: LED-ER1:TLC4.15, LED-ER1:U$3.P14
LED-ER1:B15: LED-ER1:TLC4.18, LED-ER1:U$3.P10
LED-ER1:G0: LED-ER1:TLC1.4, LED-ER1:U$6.P5
LED-ER1:G1: LED-ER1:TLC1.7, LED-ER1:U$6.P1
LED-ER1:G2: LED-ER1:TLC1.14, LED-ER1:U$6.P15
LED-ER1:G3: LED-ER1:TLC1.17, LED-ER1:U$6.P11
LED-ER1:G4: LED-ER1:TLC2.7, LED-ER1:U$1.P1
LED-ER1:G5: LED-ER1:TLC2.4, LED-ER1:U$1.P5
LED-ER1:G6: LED-ER1:TLC2.17, LED-ER1:U$1.P11
LED-ER1:G7: LED-ER1:TLC2.14, LED-ER1:U$1.P15
LED-ER1:G8: LED-ER1:TLC3.7, LED-ER1:U$2.P1
LED-ER1:G9: LED-ER1:TLC3.4, LED-ER1:U$2.P5
LED-ER1:G10: LED-ER1:TLC3.17, LED-ER1:U$2.P11
LED-ER1:G11: LED-ER1:TLC3.14, LED-ER1:U$2.P15
LED-ER1:G12: LED-ER1:TLC4.7, LED-ER1:U$3.P1
LED-ER1:G13: LED-ER1:TLC4.4, LED-ER1:U$3.P5
LED-ER1:G14: LED-ER1:TLC4.17, LED-ER1:U$3.P11
LED-ER1:G15: LED-ER1:TLC4.14, LED-ER1:U$3.P15
LED-ER1:IREF: LED-ER1:R3.1, LED-ER1:R6.1, LED-ER1:TLC1.1
LED-ER1:IREF1: LED-ER1:R1.1, LED-ER1:R2.1, LED-ER1:TLC2.1
LED-ER1:IREF2: LED-ER1:R4.1, LED-ER1:R5.1, LED-ER1:TLC3.1
LED-ER1:IREF3: LED-ER1:R7.1, LED-ER1:R8.1, LED-ER1:TLC4.1
LED-ER1:R0: LED-ER1:TLC1.3, LED-ER1:U$6.P8
LED-ER1:R1: LED-ER1:TLC1.6, LED-ER1:U$6.P4
LED-ER1:R2: LED-ER1:TLC1.13, LED-ER1:U$6.P16
LED-ER1:R3: LED-ER1:TLC1.16, LED-ER1:U$6.P12
LED-ER1:R4: LED-ER1:TLC2.6, LED-ER1:U$1.P4
LED-ER1:R5: LED-ER1:TLC2.3, LED-ER1:U$1.P8
LED-ER1:R6: LED-ER1:TLC2.16, LED-ER1:U$1.P12
LED-ER1:R7: LED-ER1:TLC2.13, LED-ER1:U$1.P16
LED-ER1:R8: LED-ER1:TLC3.6, LED-ER1:U$2.P4
LED-ER1:R9: LED-ER1:TLC3.3, LED-ER1:U$2.P8
LED-ER1:R10: LED-ER1:TLC3.16, LED-ER1:U$2.P12
LED-ER1:R11: LED-ER1:TLC3.13, LED-ER1:U$2.P16
LED-ER1:R12: LED-ER1:TLC4.6, LED-ER1:U$3.P4
LED-ER1:R13: LED-ER1:TLC4.3, LED-ER1:U$3.P8
LED-ER1:R14: LED-ER1:TLC4.16, LED-ER1:U$3.P12
LED-ER1:R15: LED-ER1:TLC4.13, LED-ER1:U$3.P16
unnamed: LED1.C, R2.2
unnamed: JP_PROG.1, U$5.GND2
unnamed: JP_PROG.2, U$5.PROG

## EAGLE design led-er-v2/led-er-v2.3d.brd

Parts:
C1, C2, C3, C7, C9: 10uF/16V; 0805
C4: 220uF+; E5-8,5
C5, C6, C8, C10: 1uF/50V; 0805
C11, C12, C13, C14: 10uF/25V; C0805
IC1, IC2, IC3, IC4: TLC59711; HTSSOP20DAP
JP5, JP9, JP12: HEADER-2X8-RIBBON; 2X08_RIBBON
JP_5V, JP_15VIN, JP_15VIN1: HEADER-1X2; 1X02_OVAL
JP_PROG: HEADER-1X2; 1X02_OVAL
JP_SIGIN: HEADER-1X2; 1X02_OVAL
JP_SIGOUT: HEADER-1X2; 1X02_OVAL
LED1: Green; CHIP-LED0805
R1, R3, R4, R5: 22K; 0805
R2: 470; 0805
R6, R8, R9: R-US_0207/9; 0207/9
R7: R-US_0207/10; 0207/10
TSR1-2450: TSR1-2450; TSR-1
U$1, U$2, U$3, U$4: MOUNTINGHOLE; MOUNTINGHOLE_3.0_PLATED
U$5: TEENSY_LEDER
U$6: HEADER-2X8-RIBBON; 2X08_RIBBON

Connections:
+15V: C3.1, C4.+, C5.1, C6.1, C8.1, C10.1, C11.2, C12.2, C13.2, C14.2, IC1.19 (VCC), IC2.19 (VCC), IC3.19 (VCC), IC4.19 (VCC), JP5.P3, JP5.P7, JP5.P9, JP5.P13, JP9.P3, JP9.P7, JP9.P9, JP9.P13, JP12.P3, JP12.P7, JP12.P9, JP12.P13, JP_15VIN.2, JP_15VIN1.2, TSR1-2450.1 (IN), U$6.P3, U$6.P7, U$6.P9, U$6.P13
GND: C1.2, C2.2, C3.2, C4.-, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, IC1.2 (GND), IC1.EXP (PAD), IC2.2 (GND), IC2.EXP (PAD), IC3.2 (GND), IC3.EXP (PAD), IC4.2 (GND), IC4.EXP (PAD), JP_5V.1, JP_15VIN.1, JP_15VIN1.1, R1.2, R2.1, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, TSR1-2450.2 (GND), U$5.GND
JP1: JP_5V.2, TSR1-2450.3 (+5V), U$5.VIN
unnamed: LED1.C, R2.2
unnamed: IC1.1 (IREF), R3.1, R6.1
unnamed: IC1.4 (OUTG0), U$6.P6
unnamed: IC1.3 (OUTR0), U$6.P8
unnamed: IC1.14 (OUTG2), U$6.P12
unnamed: IC1.13 (OUTR2), U$6.P10
unnamed: IC2.7 (OUTG1), JP5.P2
unnamed: IC2.6 (OUTR1), JP5.P4
unnamed: IC2.5 (OUTB0), JP5.P5
unnamed: IC2.4 (OUTG0), JP5.P6
unnamed: IC1.15 (OUTB2), U$6.P11
unnamed: IC1.16 (OUTR3), U$6.P14
unnamed: IC1.17 (OUTG3), U$6.P16
unnamed: IC1.18 (OUTB3), U$6.P15
unnamed: IC2.1 (IREF), R1.1, R7.1
unnamed: IC3.8 (OUTB1), JP9.P1
unnamed: IC2.13 (OUTR2), JP5.P10
unnamed: IC3.4 (OUTG0), JP9.P6
unnamed: IC4.7 (OUTG1), JP12.P2
unnamed: IC3.7 (OUTG1), JP9.P2
unnamed: IC4.6 (OUTR1), JP12.P4
unnamed: IC3.6 (OUTR1), JP9.P4
unnamed: IC2.14 (OUTG2), JP5.P12
unnamed: IC2.15 (OUTB2), JP5.P11
unnamed: IC2.16 (OUTR3), JP5.P14
unnamed: IC2.17 (OUTG3), JP5.P16
unnamed: IC2.18 (OUTB3), JP5.P15
unnamed: IC3.1 (IREF), R4.1, R8.1
unnamed: IC3.14 (OUTG2), JP9.P12
unnamed: IC2.8 (OUTB1), JP5.P1
unnamed: IC3.13 (OUTR2), JP9.P10
unnamed: IC3.15 (OUTB2), JP9.P11
unnamed: IC3.16 (OUTR3), JP9.P14
unnamed: IC3.17 (OUTG3), JP9.P16
unnamed: IC3.18 (OUTB3), JP9.P15
unnamed: IC4.1 (IREF), R5.1, R9.1
unnamed: IC2.3 (OUTR0), JP5.P8
unnamed: IC4.13 (OUTR2), JP12.P10
unnamed: IC3.5 (OUTB0), JP9.P5
unnamed: IC1.6 (OUTR1), U$6.P4
unnamed: IC1.5 (OUTB0), U$6.P5
unnamed: IC1.7 (OUTG1), U$6.P2
unnamed: IC1.8 (OUTB1), U$6.P1
unnamed: IC4.14 (OUTG2), JP12.P12
unnamed: IC4.15 (OUTB2), JP12.P11
unnamed: IC4.16 (OUTR3), JP12.P14
unnamed: IC4.17 (OUTG3), JP12.P16
unnamed: IC4.18 (OUTB3), JP12.P15
unnamed: JP_PROG.1, U$5.GND2
unnamed: JP_PROG.2, U$5.PROG
unnamed: C1.1, IC1.20 (VREG)
unnamed: C7.1, IC3.20 (VREG)
unnamed: C2.1, IC2.20 (VREG)
unnamed: IC4.11 (SCKO), JP_SIGOUT.1
unnamed: IC4.12 (SDTO), JP_SIGOUT.2
unnamed: IC3.3 (OUTR0), JP9.P8
unnamed: IC4.3 (OUTR0), JP12.P8
unnamed: IC4.4 (OUTG0), JP12.P6
unnamed: IC4.5 (OUTB0), JP12.P5
unnamed: IC4.8 (OUTB1), JP12.P1
SCKI: IC1.10 (SCKI), JP_SIGIN.2, U$5.13
SCKO1: IC1.11 (SCKO), IC2.10 (SCKI)
SCKO2: IC2.11 (SCKO), IC3.10 (SCKI)
SCKO3: IC3.11 (SCKO), IC4.10 (SCKI)
SDTI: IC1.9 (SDTI), JP_SIGIN.1, U$5.11
SDTO1: IC1.12 (SDTO), IC2.9 (SDTI)
SDTO2: IC2.12 (SDTO), IC3.9 (SDTI)
SDTO3: IC3.12 (SDTO), IC4.9 (SDTI)
VCC: C9.1, IC4.20 (VREG), LED1.A

Notes on the sheet:
CLK
DOUT

Board: 2 copper layers, 109.9 x 83.5 mm, 44 parts (0 on the bottom side), 72 nets.

## EAGLE design led-er-v3/led-er-v3.brd

Parts:
C1, C2, C3, C7, C9: 10uF/16V; 0805
C4: 220uF+; E5-8,5
C5, C6, C8, C10: 1uF/50V; 0805
C11, C12, C13, C14: 10uF 25V; 0805
IC4: TLC59711; HTSSOP20DAP
JP5, JP9, JP12: HEADER-2X8-RIBBON; 2X08_RIBBON
JP_5V, JP_15VIN, JP_15VIN1: HEADER-1X2; 1X02_OVAL
JP_PROG: HEADER-1X2; 1X02_OVAL
JP_SIGIN: HEADER-1X2; 1X02_OVAL
JP_SIGOUT: HEADER-1X2; 1X02_OVAL
LED1: Green; CHIP-LED0805
R1, R3, R4, R5: 22K; 0805
R2: 470; 0805
R6, R8, R9: R-US_0207/9; 0207/9
R7: R-US_0207/10; 0207/10
TLC1, TLC2, TLC3: TLC59711; HTSSOP20DAP
TSR1-2450: TSR1-2450; TSR-1
U$1, U$3: MOUNTINGHOLE; MOUNTINGHOLE_3.0_PLATED
U$5: TEENSY_LEDER
U$6: HEADER-2X8-RIBBON; 2X08_RIBBON

Connections:
1SCKI: JP_SIGIN.2, TLC1.10 (SCKI), U$5.13
1SDTI: JP_SIGIN.1, TLC1.9 (SDTI), U$5.11
2SCKO: TLC1.11 (SCKO), TLC2.10 (SCKI)
2SDTO: TLC1.12 (SDTO), TLC2.9 (SDTI)
3SCKO: TLC2.11 (SCKO), TLC3.10 (SCKI)
3SDTO: TLC2.12 (SDTO), TLC3.9 (SDTI)
4SCKO: IC4.10 (SCKI), TLC3.11 (SCKO)
4SDTO: IC4.9 (SDTI), TLC3.12 (SDTO)
+15V: C3.1, C4.+, C5.1, C6.1, C8.1, C10.1, C11.1, C12.1, C13.1, C14.1, IC4.19 (VCC), JP5.P3, JP5.P7, JP5.P9, JP5.P13, JP9.P3, JP9.P7, JP9.P9, JP9.P13, JP12.P3, JP12.P7, JP12.P9, JP12.P13, JP_15VIN.2, JP_15VIN1.2, TLC1.19 (VCC), TLC2.19 (VCC), TLC3.19 (VCC), TSR1-2450.1 (IN), U$6.P3, U$6.P7, U$6.P9, U$6.P13
GND: C1.2, C2.2, C3.2, C4.-, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, IC4.2 (GND), IC4.EXP (PAD), JP_5V.1, JP_15VIN.1, JP_15VIN1.1, R1.2, R2.1, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, TLC1.2 (GND), TLC1.EXP (PAD), TLC2.2 (GND), TLC2.EXP (PAD), TLC3.2 (GND), TLC3.EXP (PAD), TSR1-2450.2 (GND), U$5.GND
JP1: JP_5V.2, TSR1-2450.3 (+5V), U$5.VIN
unnamed: LED1.C, R2.2
unnamed: R3.1, R6.1, TLC1.1 (IREF)
unnamed: TLC1.8 (OUTB1), U$6.P2
unnamed: TLC1.7 (OUTG1), U$6.P1
unnamed: TLC1.6 (OUTR1), U$6.P4
unnamed: TLC1.5 (OUTB0), U$6.P6
unnamed: JP5.P2, TLC2.7 (OUTG1)
unnamed: JP5.P4, TLC2.6 (OUTR1)
unnamed: JP5.P5, TLC2.5 (OUTB0)
unnamed: JP5.P6, TLC2.4 (OUTG0)
unnamed: TLC1.4 (OUTG0), U$6.P5
unnamed: TLC1.3 (OUTR0), U$6.P8
unnamed: TLC1.15 (OUTB2), U$6.P14
unnamed: TLC1.18 (OUTB3), U$6.P10
unnamed: R1.1, R7.1, TLC2.1 (IREF)
unnamed: JP9.P1, TLC3.8 (OUTB1)
unnamed: JP5.P10, TLC2.13 (OUTR2)
unnamed: JP9.P6, TLC3.4 (OUTG0)
unnamed: IC4.7 (OUTG1), JP12.P2
unnamed: JP9.P2, TLC3.7 (OUTG1)
unnamed: IC4.6 (OUTR1), JP12.P4
unnamed: JP9.P4, TLC3.6 (OUTR1)
unnamed: JP5.P12, TLC2.14 (OUTG2)
unnamed: JP5.P11, TLC2.15 (OUTB2)
unnamed: JP5.P14, TLC2.16 (OUTR3)
unnamed: JP5.P16, TLC2.17 (OUTG3)
unnamed: JP5.P15, TLC2.18 (OUTB3)
unnamed: R4.1, R8.1, TLC3.1 (IREF)
unnamed: JP9.P12, TLC3.14 (OUTG2)
unnamed: JP5.P1, TLC2.8 (OUTB1)
unnamed: JP9.P10, TLC3.13 (OUTR2)
unnamed: TLC1.17 (OUTG3), U$6.P11
unnamed: TLC1.16 (OUTR3), U$6.P12
unnamed: TLC1.14 (OUTG2), U$6.P15
unnamed: TLC1.13 (OUTR2), U$6.P16
unnamed: JP9.P11, TLC3.15 (OUTB2)
unnamed: JP9.P14, TLC3.16 (OUTR3)
unnamed: JP9.P16, TLC3.17 (OUTG3)
unnamed: JP9.P15, TLC3.18 (OUTB3)
unnamed: IC4.1 (IREF), R5.1, R9.1
unnamed: JP5.P8, TLC2.3 (OUTR0)
unnamed: IC4.13 (OUTR2), JP12.P10
unnamed: JP9.P5, TLC3.5 (OUTB0)
unnamed: IC4.14 (OUTG2), JP12.P12
unnamed: IC4.15 (OUTB2), JP12.P11
unnamed: IC4.16 (OUTR3), JP12.P14
unnamed: IC4.17 (OUTG3), JP12.P16
unnamed: IC4.18 (OUTB3), JP12.P15
unnamed: JP_PROG.1, U$5.GND2
unnamed: JP_PROG.2, U$5.PROG
unnamed: C1.1, TLC1.20 (VREG)
unnamed: C7.1, TLC3.20 (VREG)
unnamed: C2.1, TLC2.20 (VREG)
unnamed: IC4.11 (SCKO), JP_SIGOUT.1
unnamed: IC4.12 (SDTO), JP_SIGOUT.2
unnamed: JP9.P8, TLC3.3 (OUTR0)
unnamed: IC4.3 (OUTR0), JP12.P8
unnamed: IC4.4 (OUTG0), JP12.P6
unnamed: IC4.5 (OUTB0), JP12.P5
unnamed: IC4.8 (OUTB1), JP12.P1
VCC: C9.1, IC4.20 (VREG), LED1.A

Notes on the sheet:
CLK
DOUT

Board: 2 copper layers, 49 parts (0 on the bottom side), 88 nets, no tracks yet.

Other parts of the board:
LED-ER1:C1: 10uF/16V; 0805
LED-ER1:C5: 1uF/50V; 0805
LED-ER1:C11: 10uF 25V; 0805
LED-ER1:R3: 22K; 0805
LED-ER1:R6: 0207/9
LED-ER1:TLC1: TLC59711; HTSSOP20DAP
LED-ER1:U$6: HEADER-2X8-RIBBON; 2X08_RIBBON

Their connections:
LED-ER1:+15V: LED-ER1:C5.1, LED-ER1:C11.1, LED-ER1:TLC1.19, LED-ER1:U$6.P3, LED-ER1:U$6.P7, LED-ER1:U$6.P9, LED-ER1:U$6.P13
LED-ER1:GND: LED-ER1:C1.2, LED-ER1:C5.2, LED-ER1:C11.2, LED-ER1:R3.2, LED-ER1:R6.2, LED-ER1:TLC1.2, LED-ER1:TLC1.EXP
LED-ER1:N$2: LED-ER1:R3.1, LED-ER1:R6.1, LED-ER1:TLC1.1
LED-ER1:N$3: LED-ER1:TLC1.8, LED-ER1:U$6.P2
LED-ER1:N$4: LED-ER1:TLC1.7, LED-ER1:U$6.P1
LED-ER1:N$5: LED-ER1:TLC1.6, LED-ER1:U$6.P4
LED-ER1:N$6: LED-ER1:TLC1.5, LED-ER1:U$6.P6
LED-ER1:N$11: LED-ER1:TLC1.4, LED-ER1:U$6.P5
LED-ER1:N$12: LED-ER1:TLC1.3, LED-ER1:U$6.P8
LED-ER1:N$13: LED-ER1:TLC1.15, LED-ER1:U$6.P14
LED-ER1:N$14: LED-ER1:TLC1.18, LED-ER1:U$6.P10
LED-ER1:N$32: LED-ER1:TLC1.17, LED-ER1:U$6.P11
LED-ER1:N$33: LED-ER1:TLC1.16, LED-ER1:U$6.P12
LED-ER1:N$34: LED-ER1:TLC1.14, LED-ER1:U$6.P15
LED-ER1:N$35: LED-ER1:TLC1.13, LED-ER1:U$6.P16
LED-ER1:N$56: LED-ER1:C1.1, LED-ER1:TLC1.20

## EAGLE design led-er-RJ46-single/led-er-breakout-single-RJ45.brd

Parts:
IN: HEADER-1X5; 1X05_OVAL
JP2: HEADER-1X5; 1X05_OVAL
U$1, U$2, U$3, U$4: MOUNTINGHOLE2.0; MOUNTINGHOLE_2.0_PLATED
U$6: TLC59711_BREAKOUT
X1, X2: 0446200001

Connections:
+15V: IN.3, JP2.3, U$6.P_IN_VP, X1.1, X1.5, X2.1, X2.5
GND: IN.5, JP2.1, U$6.P_IN_GND
unnamed: U$6.R0, X1.8
unnamed: U$6.G0, X1.7
unnamed: U$6.B0, X1.6
unnamed: U$6.R1, X1.4
unnamed: U$6.G1, X1.3
unnamed: U$6.B1, X1.2
unnamed: U$6.R3, X2.8
unnamed: U$6.G3, X2.7
unnamed: U$6.B3, X2.6
unnamed: U$6.R2, X2.4
unnamed: U$6.G2, X2.3
unnamed: U$6.B2, X2.2
unnamed: IN.4, U$6.P_IN_VCC
unnamed: IN.2, U$6.P_IN_CI
unnamed: IN.1, U$6.P_IN_DI
unnamed: JP2.4, U$6.P_OUT_CO
unnamed: JP2.5, U$6.P_OUT_DO

Board: 2 copper layers, 92.7 x 30.5 mm, 9 parts (0 on the bottom side), 19 nets.

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
