# Repository moksamedia/pcb-projects (continued)

## EAGLE design led-er-RJ46/led-er-2xRJ46.brd

Parts:
C1, C2, C3: 10uF/16V; 0805
C4: 220uF+; E5-8,5
C5, C6: 1uF/50V; 0805
IC1, IC2: TLC59711; HTSSOP20DAP
JP_5V, JP_5V1, JP_15VIN, JP_15VIN1: HEADER-1X2; 1X02_OVAL
JP_PROG: HEADER-1X2; 1X02_OVAL
LED1: Green; CHIP-LED0805
R1, R3: 3.3K; 0805-THM-7
R2: 470; 0805
TSR1-2450: TSR1-2450; TSR-1
U$1, U$2, U$3, U$4: MOUNTINGHOLE; MOUNTINGHOLE_3.0_PLATED
U$5: TEENSY_LEDER
X1, X2, X3, X4: 0446200001

Connections:
+15V: C3.1, C4.+, C5.1, C6.1, IC1.19 (VCC), IC2.19 (VCC), JP_5V1.2, JP_15VIN.2, TSR1-2450.1 (IN), X1.1, X1.5, X2.1, X2.5, X3.1, X3.5, X4.1, X4.5
GND: C1.2, C2.2, C3.2, C4.-, C5.2, C6.2, IC1.2 (GND), IC1.EXP (PAD), IC2.2 (GND), IC2.EXP (PAD), JP_5V.1, JP_5V1.1, JP_15VIN.1, R1.2, R2.1, R3.2, TSR1-2450.2 (GND), U$5.GND
JP1: JP_5V.2, TSR1-2450.3 (+5V), U$5.VIN
unnamed: LED1.C, R2.2
unnamed: IC1.1 (IREF), R3.1
unnamed: IC1.16 (OUTR3), X2.4
unnamed: IC1.17 (OUTG3), X2.3
unnamed: IC1.18 (OUTB3), X2.2
unnamed: IC1.13 (OUTR2), X2.8
unnamed: IC1.14 (OUTG2), X2.7
unnamed: IC1.15 (OUTB2), X2.6
unnamed: IC1.3 (OUTR0), X3.8
unnamed: IC1.4 (OUTG0), X3.7
unnamed: IC1.5 (OUTB0), X3.6
unnamed: IC1.6 (OUTR1), X3.4
unnamed: IC1.7 (OUTG1), X3.3
unnamed: IC1.8 (OUTB1), X3.2
unnamed: IC2.1 (IREF), R1.1
unnamed: IC2.3 (OUTR0), X1.8
unnamed: IC2.4 (OUTG0), X1.7
unnamed: IC2.5 (OUTB0), X1.6
unnamed: IC2.6 (OUTR1), X1.4
unnamed: IC2.7 (OUTG1), X1.3
unnamed: IC2.8 (OUTB1), X1.2
unnamed: IC2.13 (OUTR2), X4.8
unnamed: IC2.14 (OUTG2), X4.7
unnamed: IC2.15 (OUTB2), X4.6
unnamed: IC2.16 (OUTR3), X4.4
unnamed: IC2.17 (OUTG3), X4.3
unnamed: IC2.18 (OUTB3), X4.2
unnamed: IC2.11 (SCKO), JP_15VIN1.1
unnamed: IC2.12 (SDTO), JP_15VIN1.2
unnamed: JP_PROG.1, U$5.GND2
unnamed: JP_PROG.2, U$5.PROG
unnamed: C1.1, IC1.20 (VREG)
unnamed: C2.1, IC2.20 (VREG), LED1.A
SCKI: IC1.10 (SCKI), U$5.13
SCKO1: IC1.11 (SCKO), IC2.10 (SCKI)
SDTI: IC1.9 (SDTI), U$5.11
SDTO1: IC1.12 (SDTO), IC2.9 (SDTI)

Board: 2 copper layers, 96.5 x 66.0 mm, 27 parts (0 on the bottom side), 40 nets.

## Commit log

2015-11-25 updated board
2015-11-25 updated led-er 2.3b
2015-11-28 led-er- v3d, long and skinny
2015-11-30 long and skinny working
2015-11-30 slight changes
2015-11-30 removed lock
